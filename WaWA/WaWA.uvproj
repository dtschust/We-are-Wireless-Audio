# Keil uVision project WaWA.uvproj, settings and files
target Simulator (ARM-ADS)
  device: LPC2378 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: WaWA
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group Startup Code
    ./: LPC2300.s
  group System Calls
    ./: Retarget.c Serial.c
  group Source Code
    C:/Users/drew/Dropbox/We-are-Wireless-Audio/WaWA/: WaWA.c
    ./: LCD_4bit.c IRQ.c
  group Documentation
    ./: Abstract.txt
target LPC2378 Flash (ARM-ADS)
  device: LPC2378 NXP (founded by Philips)
  cpu: as above
  output: WaWA
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
